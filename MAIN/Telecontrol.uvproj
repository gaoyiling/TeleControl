# Keil uVision project Telecontrol.uvproj, settings and files
target TELECONTROL (MCS-51)
  device: STC15W104 STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: Telecontrol +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GETKEY;..\WIRELESS;..\UART
  group TELECONTROL
    ./: STARTUP.A51 main.c
  group WIRELESS
    ../WIRELESS/: wireless.c
  group GETKEY
    ../GETKEY/: get_key.c
